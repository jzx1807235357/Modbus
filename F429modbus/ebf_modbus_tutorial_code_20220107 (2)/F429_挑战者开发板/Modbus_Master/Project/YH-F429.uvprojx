# Keil uVision project YH-F429.uvprojx, settings and files
target 工程模板 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: YH-F429 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\User;..\User\gpio;..\User\tim;..\User\usart;..\User\STM32MB\modbus\ascii;..\User\STM32MB\modbus\include;..\User\STM32MB\modbus\rtu;..\User\STM32MB\modbus\tcp;..\User\STM32MB\port;..\User\STM32MB\user_app
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group STM32F4xx_HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c
  group USER
    ../User/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c system_stm32f4xx.c modbus_master_test.c
    ../User/gpio/: gpio.c
    ../User/tim/: tim.c
    ../User/usart/: usart.c
    ../User/STM32MB/port/: user_mb_app_m.c
  group DOC
    ../Doc/: readme.txt
  group MB
    ../User/STM32MB/modbus/ascii/: mbascii.c
    ../User/STM32MB/modbus/functions/: mbutils.c mbfunccoils_m.c mbfuncdisc_m.c mbfuncholding_m.c mbfuncinput_m.c mbfuncother.c
    ../User/STM32MB/modbus/rtu/: mbcrc.c mbrtu_m.c
    ../User/STM32MB/modbus/tcp/: mbtcp.c
    ../User/STM32MB/modbus/: mb_m.c
  group MB_Port
    ../User/STM32MB/port/: portevent_m.c portserial_m.c porttimer_m.c
software components: Compiler:I/O:STDERR 1.2.0
